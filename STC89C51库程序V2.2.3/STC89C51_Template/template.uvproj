# Keil uVision project template.uvproj, settings and files
target Core51Ku (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: template +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Core51_LibraryCode\Core_51;..\Core51_LibraryCode\Core_51\Hardware_Drivers\Frame_Drives;..\Core51_LibraryCode\Core_51\Hardware_Drivers;..\Core51_LibraryCode\Core_51\Hardware_Drivers\Core_Drivers\inc;..\Core51_LibraryCode\Core_51\Delay;..\Core51_LibraryCode\Module_Lib\AT24C02;..\Core51_LibraryCode\Module_Lib\DS1302;..\Core51_LibraryCode\Module_Lib\Lattice_Screen;..\Core51_LibraryCode\Module_Lib\LCD1602;..\Core51_LibraryCode\Module_Lib\Matrix_Buttons;..\Core51_LibraryCode\Module_Lib\Nixie_Tube;..\Core51_LibraryCode\Module_Lib\Temperature;..\Core51_LibraryCode\Module_Lib\XPT2406;..\Core51_LibraryCode\Core_51\Hardware_Drivers\Bus_Drive\inc;..\Core51_LibraryCode;..\STC89C51_Template;..\Core51_LibraryCode\Module_Lib\OLED12864;..\Core51_LibraryCode\Module_Lib\RC522;..\Core51_LibraryCode\Func_Lib;..\Core51_LibraryCode\Module_Lib\MAX7219;..\Core51_LibraryCode\Module_Lib\HC_SR04;..\Core51_LibraryCode\Module_Lib\Buttons;..\Core51_LibraryCode\Module_Lib\Fingerprint
  link misc: REMOVEUNUSED
  group Core51Tem
    ./: main.c core51_it.c
  group Core_51
    ../Core51_LibraryCode/Core_51/Delay/: delay.c
    ../Core51_LibraryCode/Core_51/Hardware_Drivers/Bus_Drive/src/: sim_i2c.c sim_spi.c
    ../Core51_LibraryCode/Core_51/Hardware_Drivers/Core_Drivers/src/: core51_exti.c core51_tim.c core51_uart.c core51_e2prom.c
    ../Core51_LibraryCode/: specification.c
  group Module_Lib
    ../Core51_LibraryCode/Module_Lib/Nixie_Tube/: smg.c
    ../Core51_LibraryCode/Module_Lib/LCD1602/: lcd.c
    ../Core51_LibraryCode/Module_Lib/Temperature/: temp.c
    ../Core51_LibraryCode/Module_Lib/RC522/: RC522.C
    ../Core51_LibraryCode/Module_Lib/DS1302/: ds1302.c
    ../Core51_LibraryCode/Module_Lib/AT24C02/: AT24CXX.c
    ../Core51_LibraryCode/Module_Lib/Buttons/: Buttons.c
    ../Core51_LibraryCode/Module_Lib/HC_SR04/: HC_SR04.c
    ../Core51_LibraryCode/Module_Lib/MAX7219/: MAX7219.C
    ../Core51_LibraryCode/Module_Lib/OLED12864/: OLED12864.C
    ../Core51_LibraryCode/Module_Lib/XPT2406/: XPT2046.c
    ../Core51_LibraryCode/Module_Lib/Fingerprint/: Fingerprint.C
  group Readme
    ../Readme/: Readme_Proj.txt Readme_Core51.txt Readme_ModuleLib.txt Readme_Funclib.txt
